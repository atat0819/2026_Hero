# Keil uVision project Hero.uvprojx, settings and files
target Hero (6210000::V6.21::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Hero +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../RtosTask;../user/core;../yaokongqi;../fsm;../communication;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s Hero.hex
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Alg
    ../user/core/Alg/ChassisCalculation/: CalculationBase.hpp OmniCalculation.hpp StringWheel.hpp
    ../user/core/Alg/PID/: pid.cpp
    ../user/core/Alg/FSM/: alg_fsm.cpp
    ../user/core/Alg/PowerControl/: PowerControlBase.hpp PowerControl.hpp
    ../user/core/Alg/Filter/: Filter.cpp Filter.hpp
    ../user/core/Alg/UtilityFunction/: SlopPlanning.cpp SlopePlanning.hpp
  group Bsp
    ../user/core/BSP/RemoteControl/: DT7.cpp DT7.hpp
    ../user/core/BSP/DWT/: DWT.cpp
    ../user/core/BSP/Common/StateWatch/: state_watch.cpp buzzer_manager.cpp
    ../user/core/BSP/Motor/: MotorBase.hpp
    ../user/core/BSP/Motor/Dji/: DjiMotor.hpp
    ../user/core/BSP/IMU/: HI12_imu.hpp HI12Base.hpp
  group APP
    ../user/core/APP/Heat_Detector/: Heat_Control.cpp Heat_Control.hpp
    ../user/core/APP/Referee/: RM_RefereeSystem.cpp RM_RefereeSystem.h RM_RefereeSystemCRC.cpp RM_RefereeSystemCRC.h
    ../user/core/APP/: control.cpp PowerLimit.cpp PowerLimit.h PowerLimitTask.cpp PowerLimitTask.hpp
  group RtosTask
    ../RtosTask/: can_send_task.cpp chassis_task.cpp remote_task.cpp
  group HAL
    ../user/core/HAL/CAN/impl/: can_bus_impl.cpp can_device_impl.cpp
    ../user/core/HAL/CAN/interface/: can_bus.cpp can_device.cpp
    ../user/core/HAL/CAN/: can_hal.hpp
    ../user/core/HAL/UART/: uart_hal.hpp
    ../user/core/HAL/UART/interface/: uart_bus.cpp uart_bus.hpp uart_device.hpp
    ../user/core/HAL/UART/impl/: uart_bus_impl.cpp uart_bus_impl.hpp uart_device_impl.cpp uart_device_impl.hpp
  group fsm
    ../fsm/: chassis_fsm.cpp chassis_fsm.hpp
  group communication
    ../communication/: super_cupacitor.cpp super_cupacitor.hpp gimbal_refree.cpp gimbal_refree.hpp
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0
